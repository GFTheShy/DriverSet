# Keil uVision project demo.uvprojx, settings and files
target demo (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\apps;..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\CMSIS\Include;..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\driver\Drv_led;..\driver\drv_key;..\driver\drv_bee;..\driver\exit;..\driver\drv_systick;..\driver\drv_iwdog;..\driver\USART;..\driver\timer;..\driver\pwm;..\driver\AD;..\driver\DMA;..\driver\at24c02;..\driver\iic;..\driver\drv_spi;..\driver\w25qxx;..\driver\OLED;..\driver\DHT11;..\driver\WIFI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group apps
    ../apps/: main.c stm32f4xx_it.c
    ../driver/drv_systick/: drv_systick.c
    ../driver/drv_key/: drv_key2.c
    ../driver/drv_iwdog/: drv_iwdog.c
    ../driver/USART/: usart.c
    ../driver/timer/: timer.c
    ../driver/pwm/: pwm.c
    ../driver/AD/: AD.c
    ../driver/DMA/: DMA.c
    ../driver/iic/: drv_iic.c
    ../driver/at24c02/: drv_at24c02.c
    ../driver/w25qxx/: drv_w25qxx.c
    ../driver/drv_spi/: drv_spi.c
    ../driver/OLED/: oled.c
    ../driver/DHT11/: DHT11.c
    ../driver/WIFI/: WIFI.c
  group driver
    ../driver/Drv_led/: drv_led.c
    ../driver/drv_bee/: drv_bee.c
    ../driver/drv_key/: drv_key.c
    ../driver/exit/: exit.c
  group cmsis
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group stdlib
    ../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group startup
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
